<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Prova_23_06_21\Prova_23_06_21.ewp</path>
    </project>
    <batchBuild />
</workspace>
